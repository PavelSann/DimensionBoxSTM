# Keil uVision project GateSTM.uvprojx, settings and files
target GateSTM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GateSTM
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ../Drivers/S2LP/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../Src/: stm32f2xx_it.c main.c crc.c lwip.c stm32f2xx_hal_msp.c usart.c gpio.c ethernetif.c rng.c spi.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: timeouts.c ip.c def.c mem.c inet_chksum.c stats.c tcp.c init.c tcp_in.c sys.c tcp_out.c pbuf.c memp.c raw.c udp.c netif.c dns.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ethip6.c ip6.c mld6.c ip6_frag.c inet6.c icmp6.c nd6.c dhcp6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/api/: netbuf.c api_msg.c api_lib.c err.c sockets.c netifapi.c netdb.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: demand.c multilink.c utils.c pppapi.c eap.c chap_ms.c chap-md5.c pppoe.c chap-new.c pppos.c vj.c auth.c pppol2tp.c pppcrypt.c ccp.c ecp.c ipcp.c eui64.c ppp.c fsm.c magic.c ipv6cp.c upap.c lcp.c mppe.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c ethernet.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c icmp.c etharp.c ip4_frag.c dhcp.c autoip.c ip4.c ip4_addr.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_pwr.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal.c stm32f2xx_hal_tim.c stm32f2xx_hal_flash.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rng.c stm32f2xx_hal_uart.c stm32f2xx_hal_crc.c stm32f2xx_hal_spi.c
  group Drivers/S2LP
    ../Drivers/S2LP/Src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
software components: CMSIS:CORE 4.1.0
